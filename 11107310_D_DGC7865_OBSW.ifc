Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-18T03:09:47
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Apr 18 03:09:47 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{8D5C98D4-F36D-4D81-801D-7108DA74959A}\ifc * Database version: 5507 * Database creation date: Thu Apr 18 03:09:46 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Apr 18 03:09:46 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Apr 18 03:09:46 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 23786523_D_11107310_DGC7865_OBSW, 11107310_D_DGC7865_OBSW:23786523_D_11107310_DGC7865_OBSW:205683
In: Level 1
Type - Classification: DGC7000 (Uniformat); Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Water_IN, z_Miele_Connection_Water_OUT, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW
Pset_BuildingElementProxyCommon - Reference: 23786523_D_11107310_DGC7865_OBSW
Pset_ManufacturerTypeInformation - Manufacturer: Miele
